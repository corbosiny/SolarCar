# Keil uVision project BPS-master.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F413RHTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00180000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BPS-master
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --cpp11
  c include: ..\;.\STM32F4xx_StdPeriph_Driver;.\STM32F4xx_StdPeriph_Driver\inc;.\STM32F4xx_StdPeriph_Driver\src;.\CMSIS\Device\ST\STM32F4xx\Include;.\User;.\CMSIS;.\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Src
    ./User/: main.c Current.c Voltage.c Temperature.c LTC6811.c LTC2983.c Display.c EEPROM.c WDTimer.c SPI.c UART.c FIFO.c FXAS21002CQR1.c Terminal.c
  group Inc
    ./User/: Definition.h Current.h Voltage.h Temperature.h LTC6811.h LTC2983.h Display.h EEPROM.h WDTimer.h SPI.h UART.h FIFO.h FXAS21002CQR1.h
  group StdPeriph
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_i2c.c stm32f4xx_gpio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c
software components: CMSIS:CORE 5.1.2, Device:Startup 2.6.2
